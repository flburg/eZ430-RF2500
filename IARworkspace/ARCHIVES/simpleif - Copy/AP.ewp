# IAR project AP.ewp, settings and files
configuration Debug (MSP430, debug)
  General.RTConfigPath: $TOOLKIT_DIR$\LIB\DLIB\dl430fn.h
  General.OGChipSelectMenu: MSP430F2274 MSP430F2274
  General.GStackSize2: 80
  General.GHeapSize2: 80
  General.RadioHeapSizeType: 0
  ICC430.CCDefines: MRFI_CC2500
  ICC430.IExtraOptions: -f"Configuration\smpl_config_ED.dat"; -f"Configuration\smpl_nwk_config.dat"
  ICC430.newCCIncludePaths: Applications; Components\bsp; Components\bsp\drivers; Components\bsp\boards\EZ430RF; Components\mrfi
  ICC430.CCOptLevel: 1
  ICC430.CCOptStrategy: 0
  ICC430.IccLang: 0
  XLINK.XclFile: $TOOLKIT_DIR$\CONFIG\lnk430F2274.xcl
  XLINK.XlinkStackSize: 1
configuration Release (MSP430)
  as the first configuration, except:
  General.OGChipSelectMenu: MSP430F149 MSP430F149
  ICC430.CCOptLevel: 3
  ICC430.CCOptStrategy: 1
  XLINK.XclFile: $TOOLKIT_DIR$\CONFIG\lnk430F149.xcl
  group (top)
    Applications/: main_AP.c virtual_com_cmds.c
  group bsp
    Components/bsp/: bsp.c
  group Configuration
    ../Configuration/: smpl_config_AP.dat smpl_config_ED.dat smpl_nwk_config.dat
  group mrfi
    Components/mrfi/: mrfi.c
