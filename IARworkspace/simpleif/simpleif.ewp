# IAR project simpleif.ewp, settings and files
configuration AP (MSP430, debug)
  General.OGChipSelectMenu: MSP430F2274 MSP430F2274
  General.GStackSize2: 200
  General.GHeapSize2: 0
  General.RadioHeapSizeType: 0
  ICC430.CCDefines: MRFI_CC2500
  ICC430.IExtraOptions: -f"Configuration\smpl_config_AP.dat"; -f"Configuration\smpl_nwk_config.dat"
  ICC430.newCCIncludePaths: Components\bsp; Components\bsp\drivers; Components\bsp\boards\EZ430RF; Components\mrfi; Components\SimpliciTI\nwk; Components\SimpliciTI\nwk_applications
  ICC430.CCOptLevel: 3
  ICC430.CCOptStrategy: 1
  ICC430.IccLang: 0
  XLINK.XclFile: $TOOLKIT_DIR$\CONFIG\lnk430F2274.xcl
  XLINK.XlinkStackSize: 1
  XLINK.XExtraOptions: --ks_version
configuration ED (MSP430, debug)
  as the first configuration, except:
  ICC430.IExtraOptions: -f"Configuration\smpl_config_ED.dat"; -f"Configuration\smpl_nwk_config.dat"
  group Applications
    Applications/: virtual_com_cmds.c virtual_com_cmds.h vlo_rand.h vlo_rand.s43
  group Applications/Access Point
    Applications/: main_AP.c
  group Applications/End Device
    Applications/: main_ED.c
  group Components/bsp
    Components/bsp/: bsp.c bsp.h bsp_macros.h
  group Components/mrfi
    Components/mrfi/: mrfi.c mrfi.h mrfi_defs.h
  group Configuration
    Configuration/: smpl_config_AP.dat smpl_config_ED.dat smpl_nwk_config.dat
