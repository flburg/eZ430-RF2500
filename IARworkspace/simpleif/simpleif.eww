<?xml version="1.0" encoding="iso-8859-1"?>

<workspace>
  <project>
    <path>$WS_DIR$\simpleif.ewp</path>
  </project>
  <batchBuild>
    <batchDefinition>
      <name>All Devices</name>
      <member>
        <project>simpleif</project>
        <configuration>CC2500-Access Point</configuration>
      </member>
      <member>
        <project>simpleif</project>
        <configuration>CC2500-End Device</configuration>
      </member>
    </batchDefinition>
  </batchBuild>
</workspace>


