# IAR project Sensor_Demo_AP_as_Data_Hub.ewp, settings and files
configuration CC2500 Sensor Demo-Access Point (MSP430, debug)
  General.OGChipSelectMenu: MSP430F2274 MSP430F2274
  General.GStackSize2: 200
  General.GHeapSize2: 0
  General.RadioHeapSizeType: 0
  ICC430.CCDefines: MRFI_CC2500
  ICC430.IExtraOptions: -f"Configuration\smpl_config_AP.dat"; -f"Configuration\smpl_nwk_config.dat"
  ICC430.newCCIncludePaths: Components\bsp; Components\bsp\drivers; Components\bsp\boards\EZ430RF; Components\mrfi; Components\SimpliciTI\nwk; Components\SimpliciTI\nwk_applications; C:\ti\grace_1_10_04_36\packages
  ICC430.CCOptLevel: 3
  ICC430.CCOptStrategy: 1
  ICC430.IccLang: 0
  XLINK.XclFile: $TOOLKIT_DIR$\CONFIG\lnk430F2274.xcl
  XLINK.XlinkStackSize: 1
  XLINK.XExtraOptions: --ks_version
configuration CC2500 Sensor Demo-End Device (MSP430, debug)
  as the first configuration, except:
  ICC430.IExtraOptions: -f"Configuration\smpl_config_ED.dat"; -f"Configuration\smpl_nwk_config.dat"
  ICC430.newCCIncludePaths: Components\bsp; Components\bsp\drivers; Components\bsp\boards\EZ430RF; Components\mrfi; Components\SimpliciTI\nwk; Components\SimpliciTI\nwk_applications; C:\ti\grace_1_10_04_36\packages\
  ICC430.CCOptLevel: 0
  group Applications
    Applications/: accel.c virtual_com_cmds.c virtual_com_cmds.h vlo_rand.h vlo_rand.s43
  group Applications/Access Point
    Applications/: main_AP.c
  group Applications/End Device
    Applications/: main_ED.c
  group Components/bsp
    Components/bsp/: bsp.c bsp.h bsp_macros.h
  group Components/mrfi
    Components/mrfi/: mrfi.c mrfi.h mrfi_defs.h
  group Components/nwk
    Components/simpliciti/nwk/: nwk.c nwk_api.c nwk_app.h nwk_frame.c nwk_globals.c nwk_QMgmt.c
    Components/SimpliciTI/nwk/: nwk.h nwk_api.h nwk_frame.h nwk_globals.h nwk_QMgmt.h nwk_types.h
  group Components/nwk applications
    Components/simpliciti/nwk_applications/: nwk_freq.c nwk_freq.h nwk_ioctl.c nwk_ioctl.h nwk_join.c nwk_join.h nwk_link.c nwk_link.h nwk_mgmt.c nwk_mgmt.h nwk_ping.c nwk_ping.h nwk_security.c nwk_security.h
  group Configuration
    Configuration/: smpl_config_AP.dat smpl_config_ED.dat smpl_nwk_config.dat
