# IAR project simple_hid_eb.ewp, settings and files
configuration srf04_cc2510 (8051, debug)
  General.DerivativeDescriptionFile: $TOOLKIT_DIR$\config\devices\Texas Instruments\CC2510.i51
  ICC8051.CCDefines: MRFI_CC2510; MCU_H="ioCC2510.h"; MRFI; MRFI_MAX_PAYLOAD_SIZE=53; MAX_HOPS=1; chip=2510; SRF04EB
  ICC8051.CCDiagSuppress: Pe001,Pa082,Pa084
  ICC8051.OCCDataMemoryModel: 1
  ICC8051.OCCCodeMemoryModel: 1
  ICC8051.CCIncludePath2: ../../../source/apps/simple_hid; ../../../source/Components/SimpliciTI/mrfi; ../../../source/Components/SimpliciTI/bsp; ../../../source/Components/SimpliciTI/bsp/drivers; ../../../source/Components/SimpliciTI/bsp/boards/srf04eb; ../../../source/Components/utils; ../../../source/Components/common; ../../../source/Components/common/cc8051; ../../../source/Components/targets/interface; ../../../source/Components/assembly; ../../../source/components/radios/ccxx10; ../../../source/Components/targets/srf04_soc; ../../../source/Components/targets/common
  ICC8051.CCStdIncludePath: $TOOLKIT_DIR$\INC\; $TOOLKIT_DIR$\INC\CLIB\
  ICC8051.CCOptLevel: 3
  ICC8051.CCOptStrategy: 1
  A8051.ADefines: chip=2510
  XLINK.XclFile: lnk51ew_cc2510.xcl
  group application
    ../../../source/apps/simple_hid/: simple_hid_eb.c simple_hid_mouse.c simple_hid_keyboard.c simple_hid.h
  group application/common
    ../../../source/apps/common/: mrfi_link.c mrfi_link.h
  group mrfi
    ../../../source/Components/SimpliciTI/mrfi/: mrfi.c mrfi.h mrfi_defs.h
    ../../../source/Components/SimpliciTI/mrfi/smartrf/cc2510/: smartrf_cc2510.h
  group mrfi/bsp
    ../../../source/Components/SimpliciTI/bsp/: bsp.c bsp.h bsp_macros.h
    ../../../source/Components/SimpliciTI/bsp/drivers/: bsp_buttons.h bsp_leds.h
    ../../../source/Components/SimpliciTI/bsp/drivers/code/: bsp_buttons.c bsp_leds.c bsp_generic_buttons.h bsp_generic_leds.h
    ../../../source/Components/SimpliciTI/bsp/mcus/: bsp_8051_defs.h
  group mrfi/bsp/srf04eb
    ../../../source/Components/SimpliciTI/bsp/boards/srf04eb/: bsp_board_defs.h bsp_button_defs.h bsp_driver_defs.h bsp_led_defs.h bsp_drivers.c bsp_board.c
    ../../../source/Components/SimpliciTI/bsp/boards/srf04eb/bsp_external/: mrfi_board_defs.h
  group mrfi/radios
    ../../../source/Components/SimpliciTI/mrfi/radios/family2/: mrfi_radio.c
    ../../../source/Components/SimpliciTI/mrfi/radios/common/: mrfi_f1f2.c mrfi_f1f2.h
  group utilities
    ../../../source/Components/utils/: util.h util.c util_buffer.h util_buffer.c util_lcd.h util_lcd.c
  group hal/common
    ../../../source/Components/common/: hal_int.c hal_defs.h hal_types.h
    ../../../source/Components/common/cc8051/: hal_cc8051.h adc.h adc.c
  group hal/common/io
    ../../../source/Components/targets/common/: hal_lcd_srf04.c
  group hal/interface
    ../../../source/Components/targets/interface/: hal_assert.h hal_mcu.h hal_int.h hal_button.h hal_joystick.h hal_lcd.h hal_led.h hal_rf.h
  group hal/radio/ccxx10
    ../../../source/Components/radios/ccxx10/: hal_mcu.c hal_timer_32k.c hal_rf.c clock.h clock.c
  group hal/srf04_soc
    ../../../source/Components/targets/srf04_soc/: hal_board.h hal_board.c hal_assert.c hal_button.c hal_joystick.c hal_led.c
