# IAR project rf_modem.ewp, settings and files
configuration rfusb_cc2531 (8051, debug)
  General.DerivativeDescriptionFile: $TOOLKIT_DIR$\config\devices\Texas Instruments\CC2531.i51
  ICC8051.CCDefines: BUF_SIZE=192; USB_UART; SW_TIMER; MRFI_CC2531; MCU_H="ioCC2531.h"; MRFI; MRFI_MAX_PAYLOAD_SIZE=53; MAX_HOPS=1; chip=2531
  ICC8051.CCDiagSuppress: Pe001,Pa084,Pa082
  ICC8051.OCCDataMemoryModel: 1
  ICC8051.OCCCodeMemoryModel: 1
  ICC8051.CCIncludePath2: ../../../source/Components/SimpliciTI/mrfi; ../../../source/Components/SimpliciTI/bsp; ../../../source/Components/SimpliciTI/bsp/drivers; ../../../source/Components/SimpliciTI/bsp/boards/rfusb; ../../../source/Components/utils; ../../../source/Components/targets/interface; ../../../source/Components/assembly; ../../../source/Components/common; ../../../source/Components/targets/common; ../../../source/Components/radios/cc2530; ../../../source/Components/usb/library; ../../../source/Components/targets/cc2531_dongle; ../../../source/Components/usb/library; ../../../source/Components/usb/class_cdc
  ICC8051.CCStdIncludePath: $TOOLKIT_DIR$\INC\; $TOOLKIT_DIR$\INC\CLIB\
  ICC8051.CCOptLevel: 3
  ICC8051.CCOptStrategy: 1
  A8051.ADefines: chip=2531
  XLINK.XclFile: lnk51ew_cc2531b.xcl
  group application
    ../../../source/apps/rf_modem/: rf_modem.c
  group application/common
    ../../../source/apps/common/: mrfi_link.c mrfi_link.h
  group mrfi
    ../../../source/Components/SimpliciTI/mrfi/: mrfi.c mrfi.h mrfi_defs.h
  group mrfi/bsp
    ../../../source/Components/SimpliciTI/bsp/: bsp.c bsp.h bsp_macros.h
    ../../../source/Components/SimpliciTI/bsp/drivers/: bsp_buttons.h bsp_leds.h
    ../../../source/Components/SimpliciTI/bsp/drivers/code/: bsp_buttons.c bsp_leds.c bsp_generic_buttons.h bsp_generic_leds.h
  group mrfi/bsp/rfusb
    ../../../source/Components/SimpliciTI/bsp/boards/rfusb/: bsp_board_defs.h bsp_button_defs.h bsp_driver_defs.h bsp_led_defs.h bsp_board.c bsp_drivers.c
    ../../../source/Components/SimpliciTI/bsp/boards/rfusb/bsp_external/: mrfi_board_defs.h
  group utilities
    ../../../source/Components/utils/: util.h util_lcd.h util_lcd.c util_buffer.h util_buffer.c util_lcd.h util_lcd.c util_uart.h util_uart.c
  group hal/interface
    ../../../source/Components/targets/interface/: hal_assert.h hal_mcu.h hal_int.h hal_uart.h hal_lcd.h hal_led.h hal_button.h hal_joystick.h hal_timer_32k.h hal_rf.h
  group hal/common
    ../../../source/Components/common/: hal_int.c hal_defs.h hal_types.h
    ../../../source/Components/targets/common/: hal_uart_usb.c hal_lcd_dummy.c
  group hal/common/io
    ../../../source/Components/targets/common/: hal_uart_usb.c hal_lcd_dummy.c
  group hal/radio
    ../../../source/Components/radios/cc2530/: hal_mcu.c clock.c hal_timer_32k.c
  group hal/radio/cc2530
    ../../../source/Components/radios/cc2530/: hal_mcu.c clock.c hal_timer_32k.c hal_rf.c
  group hal/rfusb
    ../../../source/Components/targets/cc2531_dongle/: hal_board.h hal_board.c hal_led.c hal_button.c hal_assert.c
  group usb/library
    ../../../source/Components/usb/library/: usb_descriptor_parser.c usb_descriptor_parser.h usb_framework.c usb_framework.h usb_framework_structs.h usb_standard_requests.h usb_standard_requests.c usb_interrupt.h usb_descriptor.h usb_reg.h usb_suspend.h
  group usb/library/cc2531
    ../../../source/Components/usb/library/cc2531/: usb_interrupt.c usb_suspend.c hal_enter_pm.s51
  group usb/class_cdc
    ../../../source/Components/usb/class_cdc/: usb_firmware_library_config.c usb_firmware_library_config.h usb_firmware_library_headers.h usb_cdc_descriptor.s51 usb_cdc.h usb_cdc_hooks.c usb_uart.c usb_uart.h
