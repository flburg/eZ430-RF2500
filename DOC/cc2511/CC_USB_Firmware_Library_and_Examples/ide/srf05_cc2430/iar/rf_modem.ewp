# IAR project rf_modem.ewp, settings and files
configuration srf05_cc2430 (8051, debug)
  General.DerivativeDescriptionFile: $TOOLKIT_DIR$\config\derivatives\Chipcon\CC2430.i51
  ICC8051.CCDefines: BUF_SIZE=192; MRFI_CC2430; MCU_H="ioCC2430.h"; MRFI; MRFI_MAX_PAYLOAD_SIZE=53; MAX_HOPS=1; chip=2430
  ICC8051.CCDiagSuppress: Pe001,Pa084
  ICC8051.OCCDataMemoryModel: 1
  ICC8051.OCCCodeMemoryModel: 1
  ICC8051.CCIncludePath2: ../../../source/Components/SimpliciTI/mrfi; ../../../source/Components/SimpliciTI/bsp; ../../../source/Components/SimpliciTI/bsp/drivers; ../../../source/Components/SimpliciTI/bsp/boards/srf04eb; ../../../source/Components/utils; ../../../source/Components/targets/interface; ../../../source/Components/assembly; ../../../source/Components/targets/srf05_soc; ../../../source/Components/common; ../../../source/Components/common/cc8051; ../../../source/Components/targets/common; ../../../source/Components/radios/cc2430
  ICC8051.CCStdIncludePath: $TOOLKIT_DIR$\INC\; $TOOLKIT_DIR$\INC\CLIB\
  ICC8051.CCOptLevel: 3
  ICC8051.CCOptStrategy: 1
  XLINK.XclFile: lnk51ew_cc2430.xcl
  group application
    ../../../source/apps/rf_modem/: rf_modem.c
  group application/common
    ../../../source/apps/common/: mrfi_link.c mrfi_link.h
  group mrfi
    ../../../source/Components/SimpliciTI/mrfi/: mrfi.c mrfi.h mrfi_defs.h
  group mrfi/bsp
    ../../../source/Components/SimpliciTI/bsp/: bsp.c bsp.h bsp_macros.h
    ../../../source/Components/SimpliciTI/bsp/drivers/: bsp_buttons.h bsp_leds.h
    ../../../source/Components/SimpliciTI/bsp/drivers/code/: bsp_buttons.c bsp_leds.c bsp_generic_buttons.h bsp_generic_leds.h
    ../../../source/Components/SimpliciTI/bsp/mcus/: bsp_8051_defs.h
  group mrfi/radios
    ../../../source/Components/SimpliciTI/mrfi/radios/family4/: mrfi_radio.c
    ../../../source/Components/SimpliciTI/mrfi/radios/family3/: mrfi_radio.c mrfi_spi.c mrfi_spi.h
  group utilities
    ../../../source/Components/utils/: util.h util_lcd.h util_lcd.c util_buffer.h util_buffer.c util_lcd.h util_lcd.c util_uart.h util_uart.c
  group hal/interface
    ../../../source/Components/targets/interface/: hal_assert.h hal_mcu.h hal_int.h hal_uart.h hal_lcd.h hal_led.h hal_button.h hal_joystick.h hal_timer_32k.h hal_rf.h
  group hal/srf05_soc
    ../../../source/Components/targets/srf05_soc/: hal_board.h hal_board.c hal_assert.c hal_led.c hal_button.c hal_joystick.c
  group hal/common
    ../../../source/Components/common/: hal_int.c hal_defs.h hal_types.h
    ../../../source/Components/common/cc8051/: hal_cc8051.h adc.h adc.c
  group hal/common/io
    ../../../source/Components/targets/common/: hal_uart_cc8051.c hal_uart_cc8051.c hal_lcd_srf05.c
  group hal/radio
    ../../../source/Components/radios/cc2430/: hal_mcu.c clock.c clock.h hal_timer_32k.c
